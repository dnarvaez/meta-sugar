DESCRIPTION = "Image with Sugar."

IMAGE_FEATURES += "splash x11-base"

LICENSE = "MIT"

inherit core-image
