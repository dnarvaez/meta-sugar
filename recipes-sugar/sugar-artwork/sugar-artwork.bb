DESCRIPTION = "Theme and icons for Sugar"
HOMEPAGE = "http://sugarlabs.org/"
BUGTRACKER = "http://bugs.sugarlabs.org/"

SRC_URI = "http://download.sugarlabs.org/sources/sucrose/glucose/sugar-artwork/sugar-artwork-0.101.0.tar.xz"

DEPENDS = "icon-naming-utils"

LICENSE = "LGPLv2.1"

inherit autotools
