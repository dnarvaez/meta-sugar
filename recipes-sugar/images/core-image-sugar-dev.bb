require core-image-sugar.bb

DESCRIPTION = "Image with Sugar for development work."

IMAGE_FEATURES += "dev-pkgs"
