DESCRIPTION = "Datastore service for Sugar"
HOMEPAGE = "http://sugarlabs.org/"
BUGTRACKER = "http://bugs.sugarlabs.org/"

SRC_URI = "http://download.sugarlabs.org/sources/sucrose/glucose/sugar-datastore/sugar-datastore-0.101.0.tar.xz"

DEPENDS = "python2"

LICENSE = "LGPLv2.1"

inherit autotools
